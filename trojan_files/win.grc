options:
  parameters:
    generate_options: qt_gui
    id: win
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: dest_ip
  id: variable
  parameters:
    value: '''192.168.0.1'''
  states: {}
- name: dest_port
  id: variable
  parameters:
    value: '4444'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: dest_ip
    port: dest_port
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', blocks_udp_sink_0, '0']

metadata:
  file_format: 1
